options:
  parameters:
    author: Cames
    generate_options: qt_gui
    id: FMCWTEST1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cent
  id: variable
  parameters:
    value: '900000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '195312'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.5'
    freq: '900000000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '2'
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\alexz\OneDrive\Desktop\SDRSAR\CNU-SDR-SAR\data\sardata.dat
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: samp_rate * 12
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: samp_rate*2
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '6280000'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '64'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: cent
    fftsize: '1024'
    showrf: 'True'
    type: float
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      #START BLOCK FOR GNU-RADIO ARDUINO CONNECTION PUT IN PYTHON SNIPPET BLOCK WITH AFTER START

      import serial #allows for serial communication to arduino
      from serial.tools import list_ports #allows for listing of available ports
      import time #allows for time.sleep() function
      def initialize_arduino_by_serial_number(target_serial_number, baudrate=9600, timeout=0.1):
          ports = list_ports.comports()
          for port in ports:
              if port.serial_number == target_serial_number:
                  try:
                      arduino = serial.Serial(port=port.device, baudrate=baudrate, timeout=timeout)
                      print(f"Arduino connected on {port.device}")
                      return arduino
                  except serial.SerialException as e:
                      print(f"Failed to connect to Arduino on {port.device}: {e}")
                      return None
          print("Arduino with specified serial number not found. Please check your connection.")
          return None
      target_serial_number = '55431313338351610291'
      arduino = initialize_arduino_by_serial_number(target_serial_number)
      time.sleep(2)
      arduino.write(b'1')
    comment: Start Block for Arduino
    section: main_after_start
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      #STOP BLOCK FOR GNU-RADIO ARDUINO CONNECTION PUT IN PYTHON SNIPPET BLOCK WITH AFTER STOP

      import serial #allows for serial communication to arduino
      from serial.tools import list_ports #allows for listing of available ports
      import time #allows for time.sleep() function
      def initialize_arduino_by_serial_number(target_serial_number, baudrate=9600, timeout=0.1):
          ports = list_ports.comports()
          for port in ports:
              if port.serial_number == target_serial_number:
                  try:
                      arduino = serial.Serial(port=port.device, baudrate=baudrate, timeout=timeout)
                      print(f"Arduino connected on {port.device}")
                      return arduino
                  except serial.SerialException as e:
                      print(f"Failed to connect to Arduino on {port.device}: {e}")
                      return None
          print("Arduino with specified serial number not found. Please check your connection.")
          return None
      target_serial_number = '55431313338351610291'
      arduino = initialize_arduino_by_serial_number(target_serial_number)
      time.sleep(2)
      arduino.write(b'2')
    comment: Stop/Reset block for arduino
    section: main_after_stop
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: cent
    dev_addr: '"addr=192.168.10.2"'
    gain0: '0'
    samp_rate: samp_rate
    sync: gps_time
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: cent
    dev_addr: '"addr=192.168.10.2"'
    gain0: '0'
    samp_rate: samp_rate
    sync: gps_time
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_f_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', uhd_usrp_sink_0, '0']
- [blocks_delay_1, '0', blocks_file_sink_0_0, '0']
- [blocks_delay_1, '0', qtgui_sink_x_0, '0']
- [blocks_head_0, '0', blocks_delay_1, '0']
- [blocks_multiply_xx_0, '0', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [blocks_vco_f_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_real_0, '0']
- [hilbert_fc_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
