options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import serial #allows for serial communication to arduino
      from serial.tools import list_ports #allows for listing of available ports
      import time #allows for time.sleep() function
      def initialize_arduino_by_serial_number(target_serial_number, baudrate=9600, timeout=0.1):
          ports = list_ports.comports()
          for port in ports:
              if port.serial_number == target_serial_number:
                  try:
                      arduino = serial.Serial(port=port.device, baudrate=baudrate, timeout=timeout)
                      print(f"Arduino connected on {port.device}")
                      return arduino
                  except serial.SerialException as e:
                      print(f"Failed to connect to Arduino on {port.device}: {e}")
                      return None
          print("Arduino with specified serial number not found. Please check your connection.")
          return None
      target_serial_number = '55431313338351610291'
      arduino = initialize_arduino_by_serial_number(target_serial_number)
      time.sleep(2)
      arduino.write(b'1')
    section: main_after_start
  states: {}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      import serial #allows for serial communication to arduino
      from serial.tools import list_ports #allows for listing of available ports
      import time #allows for time.sleep() function
      def initialize_arduino_by_serial_number(target_serial_number, baudrate=9600, timeout=0.1):
          ports = list_ports.comports()
          for port in ports:
              if port.serial_number == target_serial_number:
                  try:
                      arduino = serial.Serial(port=port.device, baudrate=baudrate, timeout=timeout)
                      print(f"Arduino connected on {port.device}")
                      return arduino
                  except serial.SerialException as e:
                      print(f"Failed to connect to Arduino on {port.device}: {e}")
                      return None
          print("Arduino with specified serial number not found. Please check your connection.")
          return None

      target_serial_number = '55431313338351610291'
      arduino = initialize_arduino_by_serial_number(target_serial_number)
      time.sleep(2)
      arduino.write(b'2')
    section: main_after_stop
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
